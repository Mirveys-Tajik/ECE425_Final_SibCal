# Keil uVision project ECE425_Final_SibCal.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECE425_Final_SibCal
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ../ECE425_final_SibCal/ECE425L_LCD_Menu_Design-main/LCD_Menu_Design/: EduBase_LCD.c GPIO.c Keypad.c SysTick_Delay.c
  group inc
    ../ECE425_final_SibCal/ECE425L_LCD_Menu_Design-main/LCD_Menu_Design/: EduBase_LCD.h GPIO.h Keypad.h SysTick_Delay.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
